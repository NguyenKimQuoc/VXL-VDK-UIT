		ORG 	00H
LJMP	MAIN
		ORG		0BH
LJMP	TF0_ISR
		ORG		1BH
LJMP	TF1_ISR
		ORG		30H
MAIN:	MOV		TMOD, #12H
		MOV		TL1, #18H
		MOV		TH1, #0FCH
		MOV		TH0, #0B7H
		MOV		IE, #8AH
		SETB	TR1
		SETB	TR0
		JMP		$
TF0_ISR:
		CLR		TR0
		CPL		P1.7
		SETB	TR0
		RETI
TF1_ISR:
		CLR		TR1
		CPL		P1.6
		MOV		TL1, #18H
		MOV		TH1, #0FCH
		SETB	TR1		
		RETI
END
	